# Keil uVision project N32G030F6S7.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G031F8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: N32G030F6S7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G030, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\device;..\CMSIS\device\startup;..\FWLIB\inc;..\USER;..\CMSIS\core;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/device/: system_n32g031.c
  group STARTUP
    ../CMSIS/device/startup/: startup_n32g031.s
  group USER
    ./: main.c n32g030_it.c
    ../HARDWARE/: delay.c
  group HARDWARE
    ../HARDWARE/: LED.c modbus_slave.c init.c flash.c
    ../../国民测试031/HARDWARE/: Proc.c
